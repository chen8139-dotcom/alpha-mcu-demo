# Keil uVision project Project.uvprojx, settings and files
target Project (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: PY32F003x8 Puya
  pack: Puya.PY32F0xx_DFP.1.2.8
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  AfterMake: cmd /c after_build_bin_sum16.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: PY32F003x8,USE_FULL_LL_DRIVER
  c include: ..\..\Drivers\CMSIS\Include;..\..\Drivers\PY32F0xx_HAL_Driver\Inc;..\Inc;..\..\Drivers\CMSIS\Device\PY32F0xx\Include;..\User\Inc;..\..\Drivers\BSP\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Common
    ../Src/: system_py32f0xx.c
    ./: startup_py32f003xx.s
  group Application
    ../Src/: main.c py32f0xx_it.c
  group Drivers/PY32F0xx_HAL_Driver
    ../../Drivers/PY32F0xx_HAL_Driver/Src/: py32f0xx_ll_utils.c py32f0xx_ll_adc.c py32f0xx_ll_tim.c py32f0xx_ll_exti.c py32f0xx_ll_gpio.c py32f0xx_ll_usart.c py32f0xx_ll_rcc.c
  group Doc
    ../: readme.txt
  group User
    ../User/Src/: user_common.c user_task.c user_light_pattern.c user_ble_pair.c user_ble_uart.c user_flash_manage.c
  group Drivers/BSP
    ../../Drivers/BSP/Src/: user_bsp_adc.c user_bsp_dma.c user_bsp_gpio.c user_bsp_key.c user_bsp_timer.c user_bsp_uart1.c user_bsp_uart2.c user_bsp_ws2812b.c user_bsp_flash.c
software components: CMSIS:CORE 5.2.0
